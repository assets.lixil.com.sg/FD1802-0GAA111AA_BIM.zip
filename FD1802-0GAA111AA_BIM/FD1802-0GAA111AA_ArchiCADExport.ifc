Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2026-04-08T07:24:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 07:24:33 2026 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\8591940e-d251-4a9c-91d6-f42d5d200fbd\b6d82916-02e2-4e58-9654-2df4e39a9146\ifc * Database version: 5507 * Database creation date: Wed Apr 08 07:24:25 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 07:24:26 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 07:24:26 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_348355
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FD1802-0GAA111AA_REVIT:FD1802-0GAA111AA, FD1802-0GAA111AA_REVIT:FD1802-0GAA111AA:348355
In: Level 1
Type - Material: American Standard - Brass - Chrome, American Standard - Plastic - Black
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: FD1802-0GAA111AA
Material: American Standard - Plastic - Black, American Standard - Brass - Chrome
Pset_DistributionFlowElementCommon - Reference: FD1802-0GAA111AA; sets with these values: 2
